options:
  parameters:
    generate_options: qt_gui
    id: lab3guia
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: LAB3_ParteEnteralab3_0
  id: LAB3_ParteEnteralab3
  parameters:
    PARAM1: 'True'
    PARAM2: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [LAB3_ParteEnteralab3_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', LAB3_ParteEnteralab3_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
