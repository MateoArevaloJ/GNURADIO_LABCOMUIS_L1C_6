options:
  parameters:
    author: Mateo Natalia
    generate_options: qt_gui
    id: ModulacionPM
    output_language: python
    title: Modulacion PM
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud Portadora
    start: '0'
    step: '0.000001'
    stop: '1'
    value: '1'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud Mensaje
    start: '0'
    step: '0.000001'
    stop: '1'
    value: '1'
  states: {}
- name: Fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Mensaje
    start: '1000'
    step: '100'
    stop: '20000'
    value: '1000'
  states: {}
- name: Kp
  id: variable_qtgui_range
  parameters:
    label: Coeficiente Kp
    start: '0'
    step: '0.000001'
    stop: '10'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: EnvolventeComplejaPM_0
  id: EnvolventeComplejaPM
  parameters:
    Ac: Ac
    Kp: Kp
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: Fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [EnvolventeComplejaPM_0, '0', qtgui_freq_sink_x_0, '0']
- [EnvolventeComplejaPM_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', EnvolventeComplejaPM_0, '0']

metadata:
  file_format: 1
