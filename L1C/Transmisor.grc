options:
  parameters:
    author: MateoNatalia
    category: '[L1C]'
    generate_options: qt_gui
    id: L1C
    output_language: python
    title: TransmisorAM
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Amplitud del modulante
    start: '0'
    step: '0.000100'
    stop: '1'
    value: '0.100'
  states: {}
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: '0.000100'
    stop: '1'
    value: '0.100'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del TX
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: Ka
  id: variable_qtgui_range
  parameters:
    label: Coeficiente Ka
    start: '0'
    step: '0.000100'
    stop: '4'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Portadora
    start: '50000000'
    step: '1000000'
    stop: '2200000000'
    value: '50000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: CalculoPotenciaComunicaciones_0
  id: CalculoPotenciaComunicaciones
  parameters:
    l_vect: '1024'
  states: {}
- name: ModuladorAML1C_0
  id: ModuladorAML1C
  parameters:
    Ac: Ac
    ka: Ka
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: '200000'
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [ModuladorAML1C_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', CalculoPotenciaComunicaciones_0, '0']
- [analog_sig_source_x_0, '0', ModuladorAML1C_0, '0']

metadata:
  file_format: 1
