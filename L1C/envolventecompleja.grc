options:
  parameters:
    author: MateoNatalia
    category: '[L1C]'
    generate_options: hb
    id: ModuladorAML1C
    output_language: python
    title: EnvolventeCompleja DSB SC
  states: {}

blocks:
- name: Ac
  id: parameter
  parameters:
    label: Amplitud de la portadora
    type: eng_float
    value: '1'
  states: {}
- name: K
  id: parameter
  parameters:
    label: Coeficiente K
    type: eng_float
    value: '1'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Ac
    type: complex
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '257'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: s(t)
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_float_0, '1', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', pad_sink_0, '0']
- [hilbert_fc_0, '0', blocks_complex_to_float_0, '0']
- [pad_source_0, '0', hilbert_fc_0, '0']

metadata:
  file_format: 1
